# Keil uVision project firmware1.0.uvprojx, settings and files
target firmware1.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: firmware1.0 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\gpio;..\SYSTEM\usart;..\SYSTEM\usart2;..\SYSTEM\usart4;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\include;..\HARDWARE\CRC;..\HARDWARE\SYSTEM;..\HARDWARE\EXTI;..\COMMUNICATE\PACKAGE;..\COMMUNICATE\COMLINK;..\MALLOC;..\COMMUNICATE\MOTOR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/SYSTEM/: system.c
    ../HARDWARE/CRC/: crc.c
    ../HARDWARE/EXTI/: exti.c
  group COMMUNICATE
    ../COMMUNICATE/PACKAGE/: package.c
    ../COMMUNICATE/COMLINK/: comlink.c
    ../COMMUNICATE/MOTOR/: motor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/gpio/: gpio.c
    ../SYSTEM/usart2/: usart2.c
    ../SYSTEM/usart4/: usart4.c
    ../SYSTEM/usart/: usart.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group README
    ../: README.TXT
  group malloc
    ../MALLOC/: malloc.c
